# Keil uVision project web.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: web +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --cpp11
  c include: .\device\inc;.\init\inc;.\it\inc;.\user\inc;.\ethernet\inc;.\web_server\inc;.\misc\inc;.\misc\ext_dev\inc;..\stm32cubef7\STM32Cube_FW_F7_V1.3.0\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\stm32cubef7\STM32Cube_FW_F7_V1.3.0\Drivers\STM32F7xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group drivers
    ../stm32cubef7/STM32Cube_FW_F7_V1.3.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c
  group user
    ./user/src/: main.cpp
  group it
    ./it/src/: stm32f7xx_it.c
  group init
    ./init/src/: init.cpp
  group device
    ./device/src/: device.cpp gpio.cpp
  group ethernet
    ./ethernet/src/: enc28j60.c ip_arp_udp_tcp.c spi_enc28j60.c sspi.cpp phy_mac_interface.cpp
  group web_server
    ./web_server/src/: web_server.c web_interface.cpp
  group extern_dev
    ./misc/ext_dev/src/: step_motor.cpp
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.1
